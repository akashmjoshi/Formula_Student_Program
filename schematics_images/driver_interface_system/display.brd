# Repository akashmjoshi/Formula_Student_Program (continued)

## EAGLE design schematics_images/power_distribution_unit/PDU.brd (continued)

Board: 2 copper layers, 60.6 x 53.8 mm, 11 parts (2 on the bottom side), 5 nets.

## EAGLE design schematics_images/data_acqusition_system/DAQBOARD.brd

Parts:
IC1: DSPIC33FJ256GP710; TQFP100-12X12
X1, X2, X3, X4: 057-026-1

Connections:
unnamed: IC1.1 (RG15), X1.1
unnamed: IC1.2 (VDD1), X1.2
unnamed: IC1.3 (RE5), X1.3
unnamed: IC1.4 (RE6), X1.4
unnamed: IC1.5 (RE7), X1.5
unnamed: IC1.6 (RC1), X1.6
unnamed: IC1.7 (RC2), X1.7
unnamed: IC1.8 (RC3), X1.8
unnamed: IC1.9 (RC4), X1.9
unnamed: IC1.10 (RG6), X1.10
unnamed: IC1.11 (RG7), X1.11
unnamed: IC1.12 (RG8), X1.12
unnamed: IC1.13 (MCLR), X1.13
unnamed: IC1.14 (RG9), X1.14
unnamed: IC1.15 (VSS2), X1.15
unnamed: IC1.16 (VDD2), X1.16
unnamed: IC1.17 (TMS), X1.17
unnamed: IC1.18 (RE8), X1.18
unnamed: IC1.19 (RE9), X1.19
unnamed: IC1.20 (RB5), X1.20
unnamed: IC1.21 (RB4), X1.21
unnamed: IC1.22 (RB3), X1.22
unnamed: IC1.23 (RB2), X1.23
unnamed: IC1.24 (RB1), X1.24
unnamed: IC1.25 (RB0), X1.25
unnamed: IC1.26 (RB6), X2.1
unnamed: IC1.27 (RB7), X2.2
unnamed: IC1.28 (RA9), X2.3
unnamed: IC1.29 (RA10), X2.4
unnamed: IC1.30 (AVDD), X2.5
unnamed: IC1.31 (AVSS), X2.6
unnamed: IC1.32 (RB8), X2.7
unnamed: IC1.33 (RB9), X2.8
unnamed: IC1.34 (RB10), X2.9
unnamed: IC1.35 (RB11), X2.10
unnamed: IC1.36 (VSS3), X2.11
unnamed: IC1.37 (VDD3), X2.12
unnamed: IC1.38 (TCK), X2.13
unnamed: IC1.39 (RF13), X2.14
unnamed: IC1.40 (RF12), X2.15
unnamed: IC1.41 (RB12), X2.16
unnamed: IC1.42 (RB13), X2.17
unnamed: IC1.43 (RB14), X2.18
unnamed: IC1.44 (RB15), X2.19
unnamed: IC1.45 (VSS4), X2.20
unnamed: IC1.46 (VDD4), X2.21
unnamed: IC1.47 (RD14), X2.22
unnamed: IC1.48 (RD15), X2.23
unnamed: IC1.49 (RF4), X2.24
unnamed: IC1.50 (RF5), X2.25
unnamed: IC1.51 (RF3), X3.1
unnamed: IC1.52 (RF2), X3.2
unnamed: IC1.53 (RF8), X3.3
unnamed: IC1.54 (RF7), X3.4
unnamed: IC1.55 (RF6), X3.5
unnamed: IC1.56 (RG3), X3.6
unnamed: IC1.57 (RG2), X3.7
unnamed: IC1.58 (RA2), X3.8
unnamed: IC1.59 (RA3), X3.9
unnamed: IC1.60 (TDI), X3.10
unnamed: IC1.61 (TDO), X3.11
unnamed: IC1.62 (VDD5), X3.12
unnamed: IC1.63 (RC12), X3.13
unnamed: IC1.64 (RC15), X3.14
unnamed: IC1.65 (VSS5), X3.15
unnamed: IC1.66 (RA14), X3.16
unnamed: IC1.67 (RA15), X3.17
unnamed: IC1.68 (RD8), X3.18
unnamed: IC1.69 (RD9), X3.19
unnamed: IC1.70 (RD10), X3.20
unnamed: IC1.71 (RD11), X3.21
unnamed: IC1.72 (RD0), X3.22
unnamed: IC1.73 (RC13), X3.23
unnamed: IC1.74 (RC14), X3.24
unnamed: IC1.75 (VSS1), X3.25
unnamed: IC1.76 (RD1), X4.1
unnamed: IC1.77 (RD2), X4.2
unnamed: IC1.78 (RD3), X4.3
unnamed: IC1.79 (RD12), X4.4
unnamed: IC1.80 (RD13), X4.5
unnamed: IC1.81 (RD4), X4.6
unnamed: IC1.82 (RD5), X4.7
unnamed: IC1.83 (RD6), X4.8
unnamed: IC1.84 (RD7), X4.9
unnamed: IC1.85 (VDDCORE), X4.10
unnamed: IC1.86 (VREG), X4.11
unnamed: IC1.87 (RF0), X4.12
unnamed: IC1.88 (RF1), X4.13
unnamed: IC1.89 (RG1), X4.14
unnamed: IC1.90 (RG0), X4.15
unnamed: IC1.91 (RA6), X4.16
unnamed: IC1.92 (RA7), X4.17
unnamed: IC1.93 (RE0), X4.18
unnamed: IC1.94 (RE1), X4.19
unnamed: IC1.95 (RG14), X4.20
unnamed: IC1.96 (RG12), X4.21
unnamed: IC1.97 (RG13), X4.22
unnamed: IC1.98 (RE2), X4.23
unnamed: IC1.99 (RE3), X4.24
unnamed: IC1.100 (RE4), X4.25

Board: 2 copper layers, 66.0 x 63.2 mm, 5 parts (0 on the bottom side), 100 nets.

## Commit log

2017-12-29 Initial Commit.
2018-01-05 Data Logger Commit
