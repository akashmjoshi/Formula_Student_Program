# Repository akashmjoshi/Formula_Student_Program

File README.md:

# Formula_Student_Program
# Responsiblity
• Established CAN communication with Motec M400 (ECU) to display real-time sensor data on the steering-wheel
• Designed and manufactured a non-contact infrared tire-temperature and brake disc temperature data logger
• Performed Gear-Change Ignition Cut using a electronic-solenoid to perform clutch-less gear shifting
• Tuned the fuel and ignition maps during chassis-dyno to achieve a flat torque curve and optimize fuel efficiency  
•  Created a Wiki-System to allow proper flow of data among all subsystems of the team - https://sites.google.com/a/orion-racing.com/orion-wiki-test/

## EAGLE design schematics_images/driver_interface_system/display.brd

Parts:
C1: C2.5/2; C2.5-2
C2, C3, C4, C5: C-US025-024X044; C025-024X044
D1, D2: 1N4446; DO35-10
DIS2, DIS3: NFD-5641AS; NFD-5641
DIS4: HD-E103; HDSP-I
IC1: PIC18F67J50; TQFP64-10X10
IC6: 7805T; TO220H
J1: 520244-4
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16: LED5MM
Q2: XTAL/S; QS
R1, R2: R-US_0309/10; 0309/10
R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R33, R34, R41: R-US_0207/10; 0207/10
S1: 10-XX; B3F-10XX
S2: 255SB
S3, S4: CK103X04
SL1: M07S; 07P
U$1: LI-CELL
X1, X2, X3, X4: 057-016-1
X5, X6, X7: MPT6; 6POL254
X8, X9: MPT5; 5POL254

Connections:
GND: C1.1, C1.2, C2.1, C3.2, C4.1, C5.1, D1.A, DIS4.3 (CC), DIS4.14 (CC), IC1.9 (VSS), IC1.20 (AVSS), IC1.25 (VSS), IC1.41 (VSS), IC1.56 (VSS), IC6.2 (GND), J1.4, LED1.K (C), LED2.K (C), LED3.K (C), LED4.K (C), LED5.K (C), LED6.K (C), LED7.K (C), LED8.K (C), LED9.K (C), LED10.K (C), LED11.K (C), LED12.K (C), LED13.K (C), LED14.K (C), LED15.K (C), LED16.K (C), R1.1, R2.1, R41.1, S1.3, S1.4 (P1), S3.A4, S4.A3, S4.A4, SL1.3, SL1.6, U$1.-@1 (-), X1.9, X2.4, X2.9, X3.9, X4.8, X6.1, X6.2, X6.3, X6.4, X6.5, X6.6, X8.1, X9.1
L1: DIS2.P$12
L2: DIS2.P$9
L3: DIS2.P$8
L4: DIS2.P$6
unnamed: IC1.7 (!MCLR), R1.2, X1.7, X8.3, X9.3
unnamed: IC1.18 (ENVREG), R10.1, X2.2
unnamed: IC1.17 (VUSB), R9.1, X2.1
unnamed: IC1.16 (PMA5/AN7/C2INB), R8.1, X1.16
unnamed: IC1.15 (RF3/DRF2/), R7.1, X1.15
unnamed: IC1.14 (RF4/D+), R6.1, X1.14
unnamed: IC1.13 (RF5/AN10/C1INB/CVREF), R5.1, X1.13
unnamed: IC1.12 (RF6/AN11/C1INA), R4.1, X1.12
unnamed: IC1.11 (RF7/!SS1!/C1OUT), R3.1, X1.11
unnamed: IC1.3 (RG0/PMA8/ECCP3/P3A), X1.3
unnamed: DIS2.P$11, R11.2
unnamed: DIS4.2 (F), R24.2, SL1.2
unnamed: IC1.2 (RE0/PMRD/P2D), R11.1, X1.2
unnamed: DIS2.P$4, R13.2
unnamed: DIS3.P$11, R25.2
unnamed: DIS2.P$1, R14.2
unnamed: DIS4.7 (E), R21.2, SL1.7
unnamed: DIS2.P$2, R15.2
unnamed: DIS2.P$5, R16.2
unnamed: IC1.4 (RG1/PMA7/TX2/CK2), X1.4
unnamed: IC1.28 (RA4/T0CKI), J1.6, X2.12
unnamed: IC1.5 (RG2/PMA6/RX2/DT2), X1.5
unnamed: IC1.6 (RG3/PMCS1/CCP4/P3D), X1.6
unnamed: IC1.1 (RE1/PMWR/P2C), R12.1, X1.1
unnamed: LED1.A, LED2.A, R10.2
unnamed: IC1.8 (RG4/PMCS2/CCP5/P1D), X1.8
unnamed: C2.2, IC1.40 (OSC2/CLKO/RA6), Q2.2, X3.8
unnamed: C3.1, IC1.39 (OSC1/CLKI/RA7), Q2.1, X3.7
unnamed: R34.1, R41.2, S3.A3
unnamed: R24.1, X3.11
unnamed: IC1.27 (RA5/AN4/C2INA), X2.11
unnamed: IC1.29 (RC1/T1OSI/ECCP2/P2A), X2.13
unnamed: IC1.31 (RC6/TX1/CK1), X2.15
unnamed: IC1.32 (RC7/RX1/DT1), X2.16
unnamed: IC1.33 (RC2/ECCP1/P1A), X3.1
unnamed: DIS2.P$10, R17.2
unnamed: IC1.34 (RC3/SCK1/SCL1), X3.2
unnamed: DIS2.P$7, R12.2
unnamed: IC1.35 (RC4/SDI1/SDA1), X3.3
unnamed: IC1.64 (RE2/PMBE/P2B), R13.1, X4.16
unnamed: IC1.21 (RA3/AN3/VREF+), J1.7, X2.5
unnamed: IC1.62 (RE4/PMA12/P3B), R14.1, X4.14
unnamed: IC1.22 (RA2/AN2/VREF-), J1.5, X2.6
unnamed: IC1.60 (RE6/PMA10/P1B), R16.1, X4.12
unnamed: DIS4.1 (A), R18.2, SL1.1
unnamed: DIS4.10 (C), R20.2
unnamed: DIS3.P$4, R27.2
unnamed: DIS4.8 (D), R22.2
unnamed: IC1.36 (RC5/SDO1/C2OUT), X3.4
unnamed: IC1.23 (RA1/AN1), J1.3, S4.A, X2.7
unnamed: IC1.30 (RC0/T1OSO/T13CKI), J1.8, X2.14
unnamed: DIS4.9 (DP), IC1.37 (RB7/KBI3/PGD), X3.5, X8.5, X9.5
unnamed: IC1.45 (RB3/INT3/PMA2), R22.1, X3.13
unnamed: IC1.47 (RB1/INT1/PMA4), R19.1, X3.15
unnamed: DIS3.P$3, IC1.49 (RD7/PMD7/!SS2), X4.1
unnamed: IC1.53 (RD3/PMD3), R29.1, X4.5
unnamed: IC1.55 (RD1/PMD1), R26.1, X4.7
unnamed: IC1.51 (RD5/PMD5/SDI2/SDA2), R31.1, X4.3
unnamed: DIS2.P$3, IC1.59 (RE7/PMA9/ECCP2/P2A), X4.11
unnamed: IC1.63 (RE3/PMA13/P3C/REFO), R15.1, X4.15
unnamed: C5.2, D2.C, IC6.1 (VI)
unnamed: LED3.A, LED4.A, R9.2
unnamed: LED5.A, LED6.A, R8.2
unnamed: LED7.A, LED8.A, R7.2
unnamed: D2.A, S2.2
unnamed: LED9.A, LED10.A, R6.2
unnamed: LED11.A, LED12.A, R5.2
unnamed: LED13.A, LED14.A, R4.2
unnamed: LED15.A, LED16.A, R3.2
unnamed: S1.1 (S), S1.2 (S1)
unnamed: J1.1, S2.1 (O), U$1.+@4 (+), X7.1, X7.2, X7.3, X7.4, X7.5, X7.6
unnamed: DIS4.11 (G), R23.2
unnamed: DIS3.P$1, R28.2
unnamed: DIS4.13 (B), R19.2
unnamed: DIS3.P$2, R29.2
unnamed: DIS3.P$5, R30.2
unnamed: DIS3.P$10, R31.2
unnamed: DIS3.P$7, R26.2
unnamed: IC1.58 (RD0/PMD0), R25.1, X4.10
unnamed: IC1.54 (RD2/PMD2), R27.1, X4.6
unnamed: IC1.52 (RD4/PMD4/SDO2), R28.1, X4.4
unnamed: IC1.50 (RD6/PMD6/SCK2/SCL2), R30.1, X4.2
unnamed: IC1.48 (RB0/FLT0/INT0), R18.1, X3.16
unnamed: IC1.46 (RB2/INT2/PMA3), R20.1, X3.14
unnamed: IC1.44 (RB4/KBI0/PMA1), R21.1, X3.12
unnamed: IC1.42 (RB6/KBI2/PGC), IC1.43 (RB5/KBI1/PMA0), R23.1, X3.10, X8.4, X9.4
unnamed: IC1.61 (RE5/PMA11/P1C), R17.1, X4.13
unnamed: R33.1, R34.2, S3.A2, S4.A2
unnamed: C4.2, D1.C, IC1.10 (VDDCORE/VCAP), IC1.19 (AVDD), IC1.26 (VDD), IC1.38 (VDD), IC6.3 (VO), R2.2, R33.2, S3.A1, S4.A1, X1.10, X2.3, X2.10, X3.6, X4.9, X5.1, X5.2, X5.3, X5.4, X5.5, X5.6, X8.2, X9.2
unnamed: IC1.24 (RA0/AN0), IC1.57 (VDD), J1.2, S3.A, X2.8
R1: DIS3.P$12
R2: DIS3.P$9
R3: DIS3.P$8
R4: DIS3.P$6

Board: 2 copper layers, 142.9 x 148.8 mm, 79 parts (1 on the bottom side), 91 nets.

## EAGLE design schematics_images/sensor_hub/sensor hub.brd

Parts:
J1, J2, J3, J4, J5, J6, J7, J13, J14, J15, J16: MTA03-156; 1X3MTA
J8, J9, J10, J11, J12: MTA02-156; 1X2MTA
X2: 5566-20

Connections:
unnamed: J13.2, X2.13
unnamed: J14.2, X2.14
unnamed: J15.2, X2.15
unnamed: J5.2, X2.5
unnamed: J6.2, X2.6
unnamed: J11.1, X2.11
unnamed: J12.1, X2.12
unnamed: J14.1, J15.1, J16.1, X2.19
unnamed: J13.3, J14.3, J16.3, X2.20
unnamed: J1.2, X2.1
unnamed: J2.2, X2.2
unnamed: J3.2, X2.3
unnamed: J4.2, X2.4
unnamed: J7.2, X2.7
unnamed: J8.1, X2.8
unnamed: J9.1, X2.9
unnamed: J10.1, X2.10
unnamed: J1.3, J2.3, J3.3, J4.3, J5.3, J6.3, J7.3, J8.2, J9.2, J10.2, J11.2, J12.2, X2.18
unnamed: J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, X2.17

Board: 2 copper layers, 98.7 x 43.2 mm, 17 parts (0 on the bottom side), 19 nets.

## EAGLE design schematics_images/voltage_regulation_system/vsrm.brd

Parts:
C1, C2, C3, C4: C2.5/4; C2.5-4
IC1: 7808T; TO220H
IC2: 7805T; TO220H
IC3: 317T; TO220H
R1, R2: R-US_0204/7; 0204/7
X1: D-SUB9-H2R09ST; H2R09ST

Connections:
GND: C1.2, C2.2, C3.2, C4.2, IC1.2 (GND), IC2.2 (GND), R2.1, X1.5, X1.6, X1.7, X1.8, X1.9
unnamed: C1.1, IC1.3 (VO), IC2.1 (VI), X1.2
unnamed: C3.1, IC3.2 (VO), R1.2, X1.4
unnamed: C2.1, IC2.3 (VO), IC3.3 (VI), X1.3
unnamed: C4.1, IC1.1 (VI), X1.1
unnamed: IC3.1 (ADJ), R1.1, R2.2

Board: 2 copper layers, 52.1 x 30.2 mm, 10 parts (1 on the bottom side), 6 nets.

## EAGLE design code/tire_temperaure_system/tire_temperature_code/3sensor.brd

Parts:
C1, C2, C3: C-TRIMM3008; 3008
R1, R2: R-US_0207/12; 0207/12
SV1: L04P
X1, X2, X3: 5566-4

Connections:
unnamed: R1.1, SV1.4, X1.4, X2.4, X3.4
unnamed: R2.1, SV1.2, X1.2, X2.2, X3.2
VDD: C1.+ (E), C2.+ (E), C3.+ (E), R1.2, R2.2, SV1.1, X1.1, X2.1, X3.1
VSS: C1.- (A), C2.- (A), C3.- (A), SV1.3, X1.3, X2.3, X3.3

Notes on the sheet:
vdd
sda
vss
scl

Board: 2 copper layers, 200.3 x 25.4 mm, 9 parts (0 on the bottom side), 4 nets.

## EAGLE design schematics_images/voltage_regulation_system/vrs.brd

Parts:
H1: MOUNT-PAD-ROUND5.5; 5,5-PAD
IC1, IC2, IC3, IC4, IC5, IC6: 7805TV; TO220V
J1: MTA04-156; 1X4MTA
LED1, LED2, LED3, LED4, LED5, LED6: LED3MM
Q1, Q2, Q3: BC547A; TO92
Q4: IRF3704L-V; TO262-V
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17: R-US_0207/10; 0207/10
SV1, SV2: MT6-8Y
T1, T2, T3: -PNP-TO92L; TO92L
X1, X2, X4, X6: AK300/2
X3, X5: D-SUB9-H2R09ST; H2R09ST
X12: D-SUB9-H3M09RA; H3M09RA

Connections:
GND2: H1.B5,5, IC1.2 (GND), IC2.2 (GND), IC3.2 (GND), IC4.2 (GND), IC5.2 (GND), IC6.2 (GND), LED1.K (C), LED3.K (C), LED5.K (C), Q1.1 (E), Q2.1 (E), Q3.1 (E), Q4.1 (G), R4.1, R9.1, R14.1, R17.2, X2.2, X3.5, X3.6, X3.7, X3.8, X3.9, X5.5, X5.6, X5.7, X5.8, X5.9, X6.2
unnamed: Q2.2 (B), R7.1
unnamed: Q2.3 (C), R6.1
unnamed: R6.2, T2.2 (B)
unnamed: Q1.2 (B), R2.1
unnamed: Q1.3 (C), R1.1
unnamed: R1.2, T1.2 (B)
unnamed: Q4.2 (D), X2.1
unnamed: LED1.A, R5.1
unnamed: J1.1, J1.2, J1.3, J1.4, LED2.K (C), R2.2, R4.2, R5.2, T1.3 (C), X12.1, X12.2, X12.3, X12.4, X12.5
unnamed: LED2.A, R3.2
unnamed: LED4.K (C), R7.2, R9.2, R10.2, SV1.1, SV1.2, SV1.3, SV1.4, SV1.5, SV1.6, SV1.7, SV1.8, T2.3 (C)
unnamed: X4.2, X12.7
unnamed: LED3.A, R10.1
unnamed: R16.2, R17.1, X12.9
unnamed: LED4.A, R8.2
unnamed: Q3.2 (B), R12.1
unnamed: Q3.3 (C), R11.1
unnamed: R11.2, T3.2 (B)
unnamed: LED6.K (C), R12.2, R14.2, R15.2, SV2.1, SV2.2, SV2.3, SV2.4, SV2.5, SV2.6, SV2.7, SV2.8, T3.3 (C)
unnamed: X4.1, X12.6
unnamed: LED5.A, R15.1
unnamed: X1.1, X12.8
unnamed: LED6.A, R13.2
unnamed: R3.1, T1.1 (E), X3.2, X5.2
unnamed: R8.1, T2.1 (E), X3.3, X5.3
unnamed: R13.1, T3.1 (E), X3.4, X5.4
unnamed: IC1.1 (VI), IC2.1 (VI), IC3.1 (VI), IC4.1 (VI), IC5.1 (VI), IC6.1 (VI), Q4.3 (S), R16.1, X1.2, X3.1, X5.1
unnamed: IC1.3 (VO), IC2.3 (VO), IC3.3 (VO), IC4.3 (VO), IC5.3 (VO), IC6.3 (VO), X6.1

Board: 2 copper layers, 104.2 x 59.7 mm, 47 parts (0 on the bottom side), 29 nets.

## EAGLE design schematics_images/data_acqusition_system/DAQ13.brd

Parts:
C1, C8, C9: C2,5-3; C2.5-3
C2, C3, C4, C5, C6, C7: C2.5/2; C2.5-2
D1: 1N4933; DO41-10
IC1: PCA82C250; DIL08
J1: MTA03-156; 1X3MTA
J2, J3: MTA02-156; 1X2MTA
LED2, LED3: LED3MM
Q1: CRYSTALHC18U-V; HC18U-V
R1, R2, R3, R4, R5, R6, R7: R-US_0204/7; 0204/7
S1: 10-XX; B3F-10XX
SL1, SL2, SL3: MA06; 06PA
X1: PN87520
X2, X3, X4, X5: AK300/8
X6, X7, X8, X9: 057-026-1
XB1: XBEE-PRO

Connections:
GND: C1.2, C2.1, C3.2, C4.1, C5.1, C6.2, C7.1, C8.2, C9.1, D1.C, IC1.2 (GND), J1.2, LED2.K (C), LED3.K (C), R7.1, S1.3, S1.4 (P1), SL1.3, SL3.1, X1.4, X6.15, X7.6, X7.11, X7.20, X8.15, X8.25, XB1.10 (GND)
unnamed: R2.2, SL1.1, X6.13
unnamed: C1.1, D1.A, R1.1, R2.1, S1.1 (S), S1.2 (S1)
unnamed: C2.2, C3.1, C4.2, C5.2, C6.1, J1.1, R1.2, R3.1, SL1.2, X6.2, X6.16, X7.12, X7.21, X8.5, X8.12, X9.11, XB1.1 (VCC)
unnamed: C7.2, X9.10
unnamed: R4.2, XB1.6 (PWM0/RSSI)
unnamed: SL1.4, X8.23
unnamed: SL1.5, X8.24
unnamed: C8.1, Q1.2, X8.14
unnamed: C9.2, Q1.1, X8.13
unnamed: R5.2, XB1.15 (ASSOC/AD5/DIO5)
unnamed: LED3.A, R5.1
unnamed: LED2.A, R4.1
unnamed: X4.7, X7.18
unnamed: X4.5, X7.16
unnamed: X1.1, X8.4
unnamed: X1.2, X8.6
unnamed: X1.3, X8.7
unnamed: X4.6, X7.17
unnamed: X2.1, X6.25
unnamed: X2.2, X6.24
unnamed: X2.3, X6.23
unnamed: X2.4, X6.22
unnamed: X2.5, X6.21
unnamed: X2.6, X6.20
unnamed: X2.7, X7.1
unnamed: X2.8, X7.2
unnamed: X4.1, X7.7
unnamed: X4.2, X7.8
unnamed: X4.3, X7.9
unnamed: X4.4, X7.10
unnamed: X4.8, X7.19
unnamed: X3.8, X6.6
unnamed: X3.7, X6.7
unnamed: X5.7, X6.4
unnamed: X3.5, X6.9
unnamed: X3.4, X6.18
unnamed: X3.3, X6.19
unnamed: X3.2, X9.16
unnamed: X3.1, X9.17
unnamed: X5.1, X9.18
unnamed: X5.2, X9.19
unnamed: X5.3, X9.23
unnamed: X5.4, X9.24
unnamed: X5.5, X9.25
unnamed: X3.6, X6.8
unnamed: X5.8, X6.5
unnamed: IC1.7 (CANH), J3.1, R6.2
unnamed: IC1.8 (RS), R7.2
unnamed: IC1.1 (TXD), J2.1, X9.4
unnamed: IC1.6 (CANL), J3.2, R6.1
unnamed: IC1.4 (RXD), J2.2, X9.6
unnamed: IC1.3 (VCC), J1.3
unnamed: SL2.5, X9.5, XB1.2 (DOUT)
unnamed: SL2.4, X9.7, XB1.3 (DIN/!CONFIG)
unnamed: X5.6, X6.3
unnamed: R3.2, X7.5

Board: 2 copper layers, 115.2 x 92.1 mm, 38 parts (0 on the bottom side), 57 nets.

## EAGLE design schematics_images/power_distribution_unit/PDU.brd

Parts:
H1, H2: MOUNT-PAD-SQUARE5.0; 5,0-PAD-SQUARE
H4, H5: MOUNT-PAD-SQUARE5.5; 5,5-PAD-SQUARE
IC1: BTS555E3146; TO220-52
Q1, Q2: IRLZ44Z; TO220BH
R1, R2: 100; R1206
SL1: 1; 03P
SM: MOUNT-PAD-SQUARE5.5; 5,5-PAD-SQUARE

Connections:
FANS: Q1.G, R1.1, SL1.3
FIS: Q2.G, R2.1, SL1.2
GND: H4.B5,5, Q1.S, Q2.S, R1.2, R2.2
H1: H1.B5
H2: H2.B5
H5: H5.B5,5
SM: IC1.1 (O1), IC1.5 (O2), SM.B5,5
SMS: IC1.2 (IN), SL1.1
